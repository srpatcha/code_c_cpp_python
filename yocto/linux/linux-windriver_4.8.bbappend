require linux-windriver-ngs-intel-x86.inc
